Commit message: update map

File: simulation/map/map/urdf/map.urdf (robot description, URDF)
Before this commit: robot map, 1 links, 0 joints
Links:
- link map: mass 10.8743305439247 -> 14.9082622392718
